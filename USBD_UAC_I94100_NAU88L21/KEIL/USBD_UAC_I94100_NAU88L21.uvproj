# Keil uVision project USBD_UAC_I94100_NAU88L21.uvproj, settings and files
target USBD_UAC_I94100_NAU88L21 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_UAC_I94100_NAU88L21
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\Library\Device\Nuvoton\I94100\Include;..\..\Library\StdDriver\inc;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\I94100;..\USBD;..\..\USBD_UAC_I94100_NAU88L21;..\NAU88L21_LIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_I94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I94100.s
    ../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group User
    ../: SysClk.c main.c
    ../USBD/: audio_class.c audio_descriptor.c
    ../NAU88L21_LIB/: NAU88L21_LIB.c
  group Libraries
    ../../Library/StdDriver/src/: clk.c crc.c dmic.c dpwm.c eadc.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c vad.c wdt.c wwdt.c
